# Keil uVision project SWM341_StdPeriph_Driver.uvprojx, settings and files
target SWM341 (6190000::V6.19::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.0.4
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: SWM341_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: KD034_LCD
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM341_StdPeriph_Driver;.\APP;.\BSP;.\IC_DRIVER;.\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./app/: main.c
    ./APP/: test.c
  group BSP
    ./BSP/: swm_delay.c swm_rgb_lcd.c swm_usart.c swm_dma2d.c jfif_parser.c
  group FATFS
    ./FATFS/: diskio.c ff.c ffunicode.c
  group CSL\StdPD
    ./CSL/SWM341_StdPeriph_Driver/: SWM341_port.c SWM341_gpio.c SWM341_exti.c SWM341_timr.c SWM341_uart.c SWM341_adc.c SWM341_dma.c SWM341_i2c.c SWM341_pwm.c SWM341_can.c SWM341_spi.c SWM341_lcd.c SWM341_flash.c SWM341_rtc.c SWM341_crc.c SWM341_wdt.c SWM341_cordic.c SWM341_sleep.c SWM341_usbd.c SWM341_div.c SWM341_sdram.c SWM341_sdio.c SWM341_dac.c SWM341_jpeg.c SWM341_dma2d.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group IC_DRIVER
    ./IC_DRIVER/: KD028_ST7701S.c KD034_ST7701S.c
